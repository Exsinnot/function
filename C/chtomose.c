#include <stdio.h>
#include <string.h>
#include <stdlib.h>
#include <time.h>

char mose[100][8] = {".-","-...","-.-.","-..",".","..-.","--.",
					"....","..",".---","-.-",".-..","--","-.",
					"---",".--.","--.-",".-.","...","-","..-",
					"...-",".--","-..-","-.--","--..","-----",
					".----","..---","...--","....-",".....",
					"-....","--...","---..","----."};
					
char moseio[100][8] = {"01","1000","1010","100","0","0010","110",
					"0000","00","0111","101","0100","11","10",
					"111","0110","1101","010","000","1","001",
					"0001","011","1001","1011","1100","11111",
					"01111","00111","00011","00001","00000",
					"10000","11000","11100","11110"};
char ch[100] = "ABCDEFGHIJKLMNOPQRSTUVWXYZ0123456789";


int main(){
	int i,j;
	char str[200];
	char mo[200][8];
	printf("Enter word : ");
	gets(str);
	strupr(str);
	for(i=0;i<200;i++){
		if(str[i] == '\0'){
			break;
		}
		if(str[i] != ' '){
			for(j=0;j<36;j++){
				if(str[i] == ch[j]){
					strcpy(mo[i],mose[j]);
					//strcpy(mo[i],moseio[j]);
					break;
				}
			}
		}
	}
	for(j=0;j<i;j++){
		printf("%s ",mo[j]);
	}
}
